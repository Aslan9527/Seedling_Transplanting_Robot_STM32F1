# Keil uVision project ii.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H2K64T Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ii
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
