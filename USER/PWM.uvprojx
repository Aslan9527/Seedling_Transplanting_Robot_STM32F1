# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\MOTOR;..\HARDWARE\TIMER4;..\HARDWARE\LIGHT;..\HARDWARE\PID_I;..\HARDWARE\PID_II;..\HARDWARE\MOVE;..\HARDWARE\PLACE;..\HARDWARE\TIMER6;..\HARDWARE\OLED;..\HARDWARE\TIMER3;..\HARDWARE\SNPID
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/TIMER4/: timer4_motor_pwm.c
    ../HARDWARE/LIGHT/: light.c
    ../HARDWARE/PID_I/: PID_I.c
    ../HARDWARE/PID_II/: PID_II.c
    ../HARDWARE/MOVE/: motor_move.c
    ../HARDWARE/PLACE/: place.c
    ../HARDWARE/TIMER6/: timer6.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIMER3/: duoji.c
    ../HARDWARE/SNPID/: pid.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group README
    ../: README.TXT
